# Repository Hmza-ahmd/my_repo

## KiCad design led-controller.kicad_pcb

Board: 2 copper layers, 100.0 x 67.0 mm, 88 parts (0 on the bottom side), 74 nets.

Parts:
C1, C2, C3, C8: 100n; C_0805
C4: 4.7u; C_0805
C5, C12: 10n; C_0805
C6: 1u; C_0805
C7, C13: 4.7u; C_1206
C9, C10, C14: 10u; C_1206
C11: 10u; C_0805
D1: 1A 40V; D_SMA
D2: D; D_MiniMELF
D3: LED; LED_0805
D4: 10V; D_MiniMELF
D5: LED_Dual_AACC; MEN-1801
J1: STLINK; Pin_Header_Straight_1x06_Pitch2.54mm
J2: PWR; PhoenixContact_MC-G_02x3.81mm_Angled
J4: GRP2; PhoenixContact_MC-G_04x3.81mm_Angled
J5: GRP3; PhoenixContact_MC-G_04x3.81mm_Angled
J6: GRP4; PhoenixContact_MC-G_04x3.81mm_Angled
J7: SWITCH; PhoenixContact_MC-G_02x3.81mm_Angled
J8: UART; Pin_Header_Straight_1x03_Pitch2.54mm
J9: UART_WINC; Pin_Header_Straight_1x03_Pitch2.54mm
L1: 15uH; Inductor_Taiyo-Yuden_NR-60xx_HandSoldering
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: Q_NMOS_GSD; SOT-23
Q13: DMP4015SK3; TO-252-2
R1: 31.2k; R_0805
R2, R32, R37, R38: 10k; R_0805
R3, R4, R5, R6, R11, R12, R13, R14, R19, R20, R21, R22: 100; R_0805
R7, R8, R9, R10, R15, R16, R17, R18, R23, R24, R25, R26, R35: 100k; R_0805
R27, R28, R29, R36: 1M; R_0805
R30, R31, R33, R34, R39, R40: 1k; R_0805
SW1: SW_Push; SW_SPST_FSMSM
TP1: TEST; Measurement_Point_Round-SMD-Pad_Small
U1: STM32F101C8Tx; LQFP-48_7x7mm_Pitch0.5mm
U2: LTV-814; DIP-4_W7.62mm_SMDSocket_SmallPads
U3: MCP16301; SOT-23-6
U4: ATWINC15x0
U5: 24LC16; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C9.1, C10.1, C14.1, D2.2, J1.1, L1.2, R1.1, R29.1, R32.1, R37.1, R38.1, TP1.1, U1.1, U1.9, U1.24, U1.36, U1.48, U4.20, U4.23, U5.8
+12V: C7.1, C13.1, D4.1, J4.1, J5.1, J6.1, Q13.3, R31.1, R36.2, U3.5
/LED_driver/CH1: R3.2, U1.10
/LED_driver/CH2: R11.2, U1.11
/LED_driver/CH3: R19.2, U1.12
/LED_driver/CH4: R4.2, U1.13
/LED_driver/CH5: R12.2, U1.40
/LED_driver/CH6: R20.2, U1.41
/LED_driver/CH7: R5.2, U1.18
/LED_driver/CH8: R13.2, U1.19
/LED_driver/CH9: R21.2, U1.42
/LED_driver/CH10: R6.2, U1.43
/LED_driver/CH11: R14.2, U1.45
/LED_driver/CH12: R22.2, U1.46
/MCU/ETH_IRQ: U1.27, U4.13
/MCU/ETH_RESET: R27.2, U1.25, U4.4
/MCU/ETH_WAKE: U1.28, U4.11
/MCU/I2C_SCL: R37.2, U1.21, U5.6
/MCU/I2C_SDA: R38.2, U1.22, U5.5
/MCU/NRST: J1.5, U1.7
/MCU/SPI_CS: U1.14, U4.16
/MCU/SPI_MISO: U1.16, U4.17
/MCU/SPI_MOSI: U1.17, U4.15
/MCU/SPI_SCK: U1.15, U4.18
/MCU/SWCLK: J1.2, U1.37
/MCU/SWDIO: J1.4, U1.34
/MCU/SWO: J1.6, U1.39
/MCU/UART_RX: J8.2, U1.31
/MCU/UART_TX: J8.1, U1.30
/Power/12V_IN: J2.1, Q13.2
/ethernet/ENABLE: R28.2, U1.26, U4.22
/ethernet/UART_RX: J9.2, U4.19
/ethernet/UART_TX: J9.1, U4.14
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.2, D3.1, D5.3, D5.4, J1.3, J2.2, J7.2, J8.3, J9.3, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, Q9.2, Q10.2, Q11.2, Q12.2, R2.2, R7.2, R8.2, R9.2, R10.2, R15.2, R16.2, R17.2, R18.2, R23.2, R24.2, R25.2, R26.2, R27.1, R28.1, R35.2, SW1.1, U1.8, U1.23, U1.35, U1.44, U1.47, U2.3, U3.2, U4.9, U4.12, U4.28, U4.29, U5.4, U5.7
unnamed: C8.1, D2.1, U3.1
unnamed: C8.2, D1.1, L1.1, U3.6
unnamed: C11.1, C12.1, U4.24
unnamed: D3.2, R30.2
unnamed: D4.2, Q13.1, R35.1
unnamed: D5.1, R40.2
unnamed: D5.2, R39.2
unnamed: J4.2, Q2.3
unnamed: J4.3, Q6.3
unnamed: J4.4, Q10.3
unnamed: J5.2, Q3.3
unnamed: J5.3, Q7.3
unnamed: J5.4, Q11.3
unnamed: J6.2, Q4.3
unnamed: J6.3, Q8.3
unnamed: J6.4, Q12.3
unnamed: J7.1, U2.2
unnamed: Q1.1, R3.1, R7.1
unnamed: Q2.1, R4.1, R8.1
unnamed: Q3.1, R5.1, R9.1
unnamed: Q4.1, R6.1, R10.1
unnamed: Q5.1, R11.1, R15.1
unnamed: Q6.1, R12.1, R16.1
unnamed: Q7.1, R13.1, R17.1
unnamed: Q8.1, R14.1, R18.1
unnamed: Q9.1, R19.1, R23.1
unnamed: Q10.1, R20.1, R24.1
unnamed: Q11.1, R21.1, R25.1
unnamed: Q12.1, R22.1, R26.1
unnamed: R1.2, R2.1, U3.3
unnamed: R29.2, U4.10
unnamed: R30.1, U1.38
unnamed: R31.2, U2.1
unnamed: R32.2, R33.2, U2.4
unnamed: R33.1, U1.33
unnamed: R34.1, U1.32
unnamed: R34.2, SW1.2
unnamed: R36.1, U3.4
unnamed: R39.1, U1.3
unnamed: R40.1, U1.4

## Commit log

2020-09-07 Create test_file
2020-09-07 Update test_file
2020-09-07 With github

Notices in the files:
led-controller.kicad_pcb:
Licensed under the TAPR Open Hardware License
